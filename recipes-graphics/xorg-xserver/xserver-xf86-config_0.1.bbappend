PR = "r500"

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
